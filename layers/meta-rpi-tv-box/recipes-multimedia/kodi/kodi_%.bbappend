DEPENDS:remove = "libnfs"